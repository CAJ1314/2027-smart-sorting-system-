# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,HSE_VALUE=8000000
  c include: .\Start;.\User;.\Library;.\System
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Start
    ./Start/: startup_stm32f40_41xxx.s stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h core_cm4.h
  group Library
    ./Library/: misc.c misc.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_rcc.c stm32f4xx_rcc.h
  group User
    ./User/: main.c stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
  group System
    ./System/: Delay.c Delay.h TB6600.c TB6600.h ObjectUART.c ObjectUART.h VisionUART.c VisionUART.h ZStepper.c ZStepper.h GripperServo.c GripperServo.h BoardUART.c BoardUART.h ILI9341.c ILI9341.h ScreenTable.c ScreenTable.h BlockPicture.h SpherePicture.h
